Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2022-02-07T16:09:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 07 16:09:03 2022 * Host: MSI * Database: C:\Users\info\AppData\Local\Temp\{61085A7F-5C02-4E2A-B6B0-6E6AD8FEFC2D}\ifc * Database version: 5507 * Database creation date: Mon Feb 07 16:09:01 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 07 16:09:01 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 07 16:09:01 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: 2019_ES_Iluminación_Estiluz_Volta_T-3533, 2019_ES_Iluminación_Estiluz_Volta_T-3533:2019_ES_Iluminación_Estiluz_Volta_T-3533:360488
In: Level 1
Type - Classification: D5020230 Lighting - High Intensity (Uniformat); Material: Aluminio, anodizado, negro
Type - Data - Carga Maxima Sensible: 0 W; Carga Maxima Sensible De Espacio: 0 W; Carga Sensible a Calor Radiante: 0; Es Exterior: no; Factor Mantenimiento: 0; Numero de Fuentes: 1; Vataje Total: 5.8 W
Type - Electrical - Ballast Number of Poles: 1; Ballast Voltage: 220 V; Lamp: LED; Load Classification: Lighting - Dwelling Unit; Wattage Comments: 40
Type - Electrical - Loads - Apparent Load: 6.1 W; Clase Estandar Aislamiento: III; Codigo_IP: IP 20; Corriente Nominal: 0 A; Factor Potencia: 0; Frecuencia Nominal: 50 Hz; Numero de Polos: 1; Tension Nominal: 220 V; Toma Tierra Proteccion: no
Type - General - Coste Mantenimiento: 0; Garantia Extendida: no; Periodo Garantia: 2 años
Type - Green Building Properties - Acidificacion Atmosferica por Unidad: 0; Agua Consumida por Unidad: 0; Cambio Climatico por Unidad: 0; Destruccion Capa Ozono Estratosferica por Unidad: 0; Energia consumida: 0; Energia No Renovable Consumida por Unidad: 0; Energia Primaria Total Consumida por Unidad: 0; Energia Renovable Consumida por Unidad: 0; Eutrofizacion por Unidad: 0; Falta de Recursos por Unidad: 0; Formacion Fotoquimica Ozono por Unidad: 0; Residuo Inerte por Unidad: 0; Residuo Radioactivo por Unidad: 0; Residuos No Peligrosos por Unidad: 0; Residuos Peligrosos por Unidad: 0
Type - Identity Data - Assembly Code: D5020230; Assembly Description: Lighting - High Intensity; Autor: Bimetica Parametric Design Services S.L. - S. Cristóbal Bernal; Codigo: T-3533; Description: Foco orientable con cabezal cilíndrico y driver remoto; Email Contacto: estiluz@estiluz.com; Fecha Emision Elemento BIM: 07.02.2022; Fecha Vencimiento Elemento BIM: 07.02.2023; Historial: (RVT2019) Creación del Elemento.; Manufacturer: Estiluz S.A.; Marcado CE: yes; Model: T-3533; Numero de Licencia: XXX-XXXX9536; OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights; Plataforma descaga contenido BIM: www.bimetica.com; Referencia: T-3533; Serie: Volta; Soporte tecnico BIM: https://bimsupport.info/es/fabricantes/estiluz-s-a/; Telefono Contacto: +34 972 720 125; Titular: Estiluz S.A.; Type Name: 2019_ES_Iluminación_Estiluz_Volta_T-3533; URL Perfil BIM: https://bimetica.com/es/objeto-bim-estiluz-luminaria-foco-volta-t-3533-10409.html; Version: RVT2019; Version Estandar GDO-BIM: GDO-BIM V02
Type - Materials and Finishes - Foco: Vidrio, alta aluminancia; Material: Aluminio, anodizado, negro
Type - Other - Category: Lighting Fixtures; Case Angle: 45 deg; Family Name: 2019_ES_Iluminación_Estiluz_Volta_T-3533; Lamp Half Width: 50 mm
Type - Photometrics - Ballast Loss: 0.88; Color Filter: 16777215; Dimming Lamp Color Temperature Shift: <None>; Efficacy: 124 s3*lm/kg/m2; Espectro: 0; Factor de mantenimiento de la lampara: 0; Illuminance: 6.21009 lx; indice de reproduccion cromatica: 90; Initial Color: 0; Initial Color Temperature: 2700 K; Initial Intensity: 0; Lamp Lumen Depreciation: 1; Lamp Tilt Loss: 1; Light Loss Factor: 0; Light Source Definition (family): Point+Photometric Web; Luminaire Dirt Depreciation: 1; Luminous Flux: 725 lm; Luminous Intensity: 57.6937 cd; Photometric Web File: DS1T5.IES; Potencia nominal del emisor de luz: 0 W; Surface Depreciation Loss: 1; Temperatura del color: -273.15 kg/K/s3; Temperature Loss: 1; Tilt Angle: -120 deg; Tipo de compensacion de lampara: Controlador constante de corriente; Total Light Loss Factor: 0.88; Voltage Loss: 1; Wattage: 5.84677 W
Pset_BuildingElementProxyCommon - Reference: 2019_ES_Iluminación_Estiluz_Volta_T-3533:2019_ES_Iluminación_Estiluz_Volta_T-3533
Pset_ManufacturerTypeInformation - Manufacturer: Estiluz S.A.
Constraints - Level: Level: Level 1
Dimensions - Area: 0.00552112 m2; Volume: 0.0000753451 m3
Electrical - Circuiting - Electrical Data: 220 V/1-6 VA
Identity Data - Mark: 1
Other - Family: 2019_ES_Iluminación_Estiluz_Volta_T-3533: 2019_ES_Iluminación_Estiluz_Volta_T-3533; Family and Type: 2019_ES_Iluminación_Estiluz_Volta_T-3533: 2019_ES_Iluminación_Estiluz_Volta_T-3533; Host Id: Compound Ceiling: 600 x 1200mm grid; Type: 2019_ES_Iluminación_Estiluz_Volta_T-3533: 2019_ES_Iluminación_Estiluz_Volta_T-3533; Type Id: 2019_ES_Iluminación_Estiluz_Volta_T-3533: 2019_ES_Iluminación_Estiluz_Volta_T-3533
Phasing - Phase Created: New Construction
