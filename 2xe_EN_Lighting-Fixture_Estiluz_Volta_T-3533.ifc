Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2022-02-07T16:11:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 07 16:11:40 2022 * Host: MSI * Database: C:\Users\info\AppData\Local\Temp\{3DC334DF-56D3-4606-8A50-A75834148A91}\ifc * Database version: 5507 * Database creation date: Mon Feb 07 16:11:40 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 07 16:11:40 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 07 16:11:40 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: 230V / Typ* 578 lumens / Dimmable Triac, 2019_EN_Lighting-Fixture_Estiluz_Volta_T-3533:230V / Typ* 578 lumens / Dimmable Triac:360530
In: Level 1
Type - Classification: D5020230 Lighting - High Intensity (Uniformat); Material: Aluminum, Anodized Black
Type - Data - Has Protective Earth: no; Insulation Standard Class: III; IP_Code: IP 20; Is External: no; Nominal Frequency: 50 Hz; Number of Poles: 1; Power Factor: 0; RatedCurrent: 350 A; Rated Voltage: 220 V
Type - Electrical - Ballast Number of Poles: 1; Ballast Voltage: 120 V; Lamp: LED; Load Classification: Lighting - Dwelling Unit; Wattage Comments: 40
Type - Electrical - Lighting - Maintenance Factor: 0; Maximum Plenum Sensible Load: 0 W; Maximum Space Sensible Load: 0 W; Number of Sources: 1; Sensible Load To Radiant: 0; Total Wattage: 5.8 W
Type - Electrical - Loads - Apparent Load: 6.1 W
Type - General - Is Extended Warranty: no; Maintenance Cost: 0; Warranty Period: 2 years
Type - Green Building Properties - Atmospheric Acidification Per Unit: 0; Climate Change Per Unit: 0; Energy Spent: 0; Eutrophication Per Unit: 0; Hazardous Waste Per Unit: 0; Inert Waste Per Unit: 0; NonHazardous Waste Per Unit: 0; Non Renewable Energy Consumption Per Unit: 0; Photochemical Ozone Formation Per Unit: 0; Radioactive Waste Per Unit: 0; Renewable Energy Consumption Per Unit: 0; Resource Depletion Per Unit: 0; Stratospheric Ozone Layer Destruction Per Unit: 0; Total Primary Energy Consumption Per Unit: 0; Water Consumption Per Unit: 0
Type - Identity Data - Assembly Code: D5020230; Assembly Description: Lighting - High Intensity; Author: Bimetica Parametric Design Services S.L. - S. Cristóbal Bernal; BIM Content Download Platform: www.bimetica.com; BIM Eelement Expiry Date: 07.02.2023; BIM Element Issue Date: 07.02.2022; BIM Profile URL: https://bimetica.com/es/bim-object-estiluz-lighting-fixture-volta-t-3533-10410.html; BIMsupport: https://bimsupport.info/es/fabricantes/estiluz-s-a/; CE Mark: yes; Code: T-3533; Contact Email: estiluz@estiluz.com; Description: Ceiling Spot Light, with cilindrical directional lamp and remote driver.; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Creation of Element; License Number: XXX-XXXX9536; Manufacturer: Estiluz S.A.; Model: T-3533; OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights; Owner: Estiluz S.A.; Reference: T-3533; Series: Volta; Telephone Contact: +34 972 720 125; Type Name: 230V / Typ* 578 lumens / Dimmable Triac; Version: RVT2019
Type - Materials and Finishes - Lamp Material: Glass, High luminance; Material: Aluminum, Anodized Black
Type - Other - Category: Lighting Fixtures; Case Angle: 45 deg; Family Name: 2019_EN_Lighting-Fixture_Estiluz_Volta_T-3533; Lamp Half Width: 50 mm
Type - Photometrics - Ballast Loss: 0.88; Ballast type: Constant current driver; Chromatic reproduction index: 90; Color Filter: 16777215; Color temperature: -273.15 kg/K/s3; Dimming Lamp Color Temperature Shift: <None>; Efficacy: 578 s3*lm/kg/m2; Factor de mantenimiento de la lampara: 0; Illuminance: 6.21009 lx; Initial Color: 0; Initial Color Temperature: 2700 K; Initial Intensity: 0; Lamp Lumen Depreciation: 1; Lamp Tilt Loss: 1; Light emission nominal load: 6.1 W; Light Loss Factor: 0; Light Source Definition (family): Point+Photometric Web; Luminaire Dirt Depreciation: 1; Luminous Flux: 725 lm; Luminous Intensity: 57.6937 cd; Photometric Web File: DS1T5.IES; Spectrum: 0; Surface Depreciation Loss: 1; Temperature Loss: 1; Tilt Angle: -120 deg; Total Light Loss Factor: 0.88; Voltage Loss: 1; Wattage: 1.25433 W
Pset_BuildingElementProxyCommon - Reference: T-3533
Pset_ManufacturerTypeInformation - Manufacturer: Estiluz S.A.
Constraints - Level: Level: Level 1
Dimensions - Area: 0.00552112 m2; Volume: 0.0000753451 m3
Electrical - Circuiting - Electrical Data: 120 V/1-6 VA
Identity Data - Mark: 1
Other - Family: 2019_EN_Lighting-Fixture_Estiluz_Volta_T-3533: 230V / Typ* 578 lumens / Dimmable Triac; Family and Type: 2019_EN_Lighting-Fixture_Estiluz_Volta_T-3533: 230V / Typ* 578 lumens / Dimmable Triac; Host Id: Compound Ceiling: 600 x 1200mm grid; Type: 2019_EN_Lighting-Fixture_Estiluz_Volta_T-3533: 230V / Typ* 578 lumens / Dimmable Triac; Type Id: 2019_EN_Lighting-Fixture_Estiluz_Volta_T-3533: 230V / Typ* 578 lumens / Dimmable Triac
Phasing - Phase Created: New Construction
